# Keil uVision project LCD_Project.uvproj, settings and files
target LCD_Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_Project
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.c initialization.c Delay.c Documentation.c tm4c123gh6pm.h Dec_char.c functions.h change_decimal.c compute.c LED.c Get_Key.c key_Pad_init.c
    ../KeyPad/: keyPad.h
